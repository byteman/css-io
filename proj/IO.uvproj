# Keil uVision project IO.uvproj, settings and files
target IO (MCS-51)
  device: STC12C5A16S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(45000000) MODP2
  output: IO +hex
  c flags: Optimize=8 SizeSpeed=1
  group SRC
    ../src/: main.c STARTUP.A51 STC12C5A.H mcp3208.c usart1.c
